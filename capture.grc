options:
  parameters:
    generate_options: qt_gui
    id: capture
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '7800'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '50'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.09'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: int(float(sample_rate/baud_rate)/decimation)
    max_iter: '4000'
    scale: float(1/int(float(sample_rate/baud_rate)/decimation))
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7878'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: digital_binary_slicer_fb_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0'
    gain_omega: '0'
    mu: '0'
    omega: float(float(sample_rate/baud_rate)/decimation)
    omega_relative_limit: '0'
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '40'
    freq0: carrier_freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: sample_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    marker1: '7'
    size: '3000'
    srate: int(sample_rate/decimation)
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_1_1, '0']
- [digital_binary_slicer_fb_2, '0', blocks_udp_sink_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_2, '0']
- [osmosdr_source_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
