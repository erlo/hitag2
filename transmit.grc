options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: transmit
    output_language: python
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: frame
  id: variable
  parameters:
    value: open('/tmp/frametosend').read().strip()
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '7800'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/symbol_rate)
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: '[ int (x) for x in frame ]'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: carrier_freq
    gain0: '20'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_repeat_0, '0', osmosdr_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
